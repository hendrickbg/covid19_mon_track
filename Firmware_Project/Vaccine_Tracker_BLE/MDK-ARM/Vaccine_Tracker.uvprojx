# Keil uVision project Vaccine_Tracker.uvprojx, settings and files
target Vaccine_Tracker (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Vaccine_Tracker +hex
  AfterMake: fromelf.exe --bin Objects\Vaccine_Tracker.axf --output Objects\Vaccine_Tracker.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 USER_BUTTON=BSP_PUSH1 CONFIG_HW_LS_RO BLE_STACK_BASIC_CONF CONFIG_DEVICE_BLUENRG_LP STEVAL_IDB011V1
  c include: ..\Core\Inc;..\Drivers\Peripherals_Drivers\Inc;..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\Middlewares\ST\hal\Inc;..\Drivers\CMSIS\Include;..\Middlewares\ST\BLE_Application\layers_inc;..\Middlewares\ST\Bluetooth_LE\inc;..\Middlewares\ST\NVMDB\Inc;..\HT_APP\Inc;..\Display_API\BSP\Inc;..\Display_API\Fonts\Inc;..\Middlewares\ST\BLE_Application\Profiles\Inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\Vaccine_Tracker.sct
  group Drivers/CMIS
    ../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_hal.c bluenrg_lp_hal_cortex.c bluenrg_lp_hal_crc.c bluenrg_lp_hal_crc_ex.c bluenrg_lp_hal_dma.c bluenrg_lp_hal_exti.c bluenrg_lp_hal_flash.c bluenrg_lp_hal_flash_ex.c bluenrg_lp_hal_gpio.c bluenrg_lp_hal_i2c.c bluenrg_lp_hal_i2c_ex.c bluenrg_lp_hal_i2s.c bluenrg_lp_hal_irda.c bluenrg_lp_hal_iwdg.c bluenrg_lp_hal_pka.c bluenrg_lp_hal_power_manager.c bluenrg_lp_hal_pwr.c bluenrg_lp_hal_pwr_ex.c bluenrg_lp_hal_radio.c bluenrg_lp_hal_rcc.c bluenrg_lp_hal_rcc_ex.c bluenrg_lp_hal_rng.c bluenrg_lp_hal_rtc.c bluenrg_lp_hal_rtc_ex.c bluenrg_lp_hal_smartcard.c bluenrg_lp_hal_smartcard_ex.c bluenrg_lp_hal_smbus.c bluenrg_lp_hal_spi.c bluenrg_lp_hal_spi_ex.c bluenrg_lp_hal_tim.c bluenrg_lp_hal_tim_ex.c bluenrg_lp_hal_uart.c bluenrg_lp_hal_uart_ex.c bluenrg_lp_hal_usart.c bluenrg_lp_hal_usart_ex.c bluenrg_lp_hal_vtimer.c bluenrg_lp_ll_adc.c bluenrg_lp_ll_crc.c bluenrg_lp_ll_dma.c bluenrg_lp_ll_exti.c bluenrg_lp_ll_flash.c bluenrg_lp_ll_gpio.c bluenrg_lp_ll_i2c.c bluenrg_lp_ll_lpuart.c bluenrg_lp_ll_pka.c bluenrg_lp_ll_pwr.c bluenrg_lp_ll_radio.c bluenrg_lp_ll_rcc.c bluenrg_lp_ll_rng.c bluenrg_lp_ll_rtc.c bluenrg_lp_ll_spi.c bluenrg_lp_ll_tim.c bluenrg_lp_ll_timer.c bluenrg_lp_ll_usart.c bluenrg_lp_ll_utils.c
  group Core/Src
    ../Core/Src/: adc.c bluenrg_lp_it.c dma.c gpio.c main.c rtc.c spi.c tim.c usart.c
  group Middlewares/BLE_Stack
    ../Middlewares/ST/Bluetooth_LE/src/: stack_user_cfg.c
    ../Middlewares/ST/Bluetooth_LE/library/: libbluenrg_lp_stack.a
  group Middlewares/Cryptolib
    ../Middlewares/ST/cryptolib/: libcrypto.a
  group Middlewares/HAL
    ../Middlewares/ST/hal/Src/: blue_unit_conversion.s clock.c context_switch.s gp_timer.c hal_miscutil.c miscutil.c osal.c
  group Middlewares/NVM
    ../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/Profiles
    ../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group HT_APP
    ../HT_APP/Src/: HT_app.c HT_ble_api.c HT_gatt_db.c HT_sensor.c
  group Display_API/BSP/Src
    ../Display_API/BSP/Src/: epd2in9.c epdif.c epdpaint.c imagedata.c
  group Display_API/Fonts/Src
    ../Display_API/Fonts/Src/: font8.c font12.c font16.c font20.c font24.c
software components: CMSIS:CORE 5.3.0
